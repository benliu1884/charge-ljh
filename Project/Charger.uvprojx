# Keil uVision project Charger.uvprojx, settings and files
target Charger (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Charger +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: HT501x
  c include: ..\Src;..\BSP;..\Libraries\HT60xx_StdPeriph_Driver\src;..\Libraries\HT60xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM0\CoreSupport;..\Libraries\CMSIS\CM0\DeviceSupport;..\Libraries\HT60xx_StdPeriph_Driver;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\MemMang;..\Middlewares\FreeRTOS\CMSIS_RTOS;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Config
    ../Src/: includes.h
  group Src
    ../Src/: main.c ht6xxx_it.c mainTask.c charger.c
  group BSP
    ../BSP/: pmu.c cmu.c rtc.c delay.c emu.c uart.c FIFO.c sim_pwm.c os_timer.c
  group Drivers/Lib
    ../Libraries/HT60xx_StdPeriph_Driver/src/: ht6xxx_aes&rand.c ht6xxx_cmu.c ht6xxx_dma.c ht6xxx_ecc.c ht6xxx_exti.c ht6xxx_flash.c ht6xxx_gpio.c ht6xxx_iic.c ht6xxx_lcd.c ht6xxx_pmu.c ht6xxx_reset.c ht6xxx_rtc.c ht6xxx_spi.c ht6xxx_tbs.c ht6xxx_tdes&rand.c ht6xxx_timer.c ht6xxx_uart&7816.c ht501x_emu.c ht501x_keyscan.c
  group Drivers/CMSIS
    ../Libraries/CMSIS/CM0/DeviceSupport/: system_ht6xxx.c
    ../Libraries/CMSIS/CM0/CoreSupport/: core_cm0.c
  group Startup
    ../Libraries/Startup/Keil/: startup_ht501x.s
